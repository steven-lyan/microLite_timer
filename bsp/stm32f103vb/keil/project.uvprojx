# Keil uVision project project.uvprojx, settings and files
target microLite_timer_prj (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103VB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: microLite_timer +hex
  c flags: v6Lang=3 v6LangP=3
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\..\..\src;..\..\..\test;..\Libraries
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group microLite_timer/src
    ../../../src/: microLite_timer.c microLite_timer.h
  group microLite_timer/test
    ../../../test/: test1_period.c test2_shot.c test3_misc.c test4_error.c test_5.c
  group main
    ../: main.c
    ./: startup_stm32f10x_md.s
software components: CMSIS:CORE 5.4.0
